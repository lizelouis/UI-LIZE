# Keil uVision project RM2018.uvprojx, settings and files
target F4 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2018
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40XX,USE_STDPERIPH_DRIVER
  c misc: --gnu -Dlittle_endian
  c include: ..\MAKOS;..\MAKOS\includes;..\MAKOS\kernel;..\MAKOS\migration;..\STM32F4\inc;..\system;..\user;..\user\device\mpu;..\user\device;..\user\app;..\STM32F4;..\user\driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../user/: main.c
  group app
    ../user/app/: task_led.c task_init.c task_remote.c task_chassis.c task_holder.c task_shoot.c task_bullet.c task_clip.c task_camera_move.c task_drag.c task_give.c task_guard.c task_receiver_fix.c task_judge.c task_car_rise_engineer.c task_car_rise_hero.c data_fifo.c judgement_info.c protocol.c communicate.c task_uartdma_test.c task_judge_temp.c UI.c task_oled.c data_save.c
  group user_lib
    ../user/app/: task_fl_test.c flash_data.c mak_pid.c holder_pid.c pid.c protocol.c
  group device
    ../user/device/: led.c Lower machine.c motor.c dbus.c supply_motor.c oled.c keyboard.c
  group mpu
    ../user/device/mpu/: MPU6050.c MPU6050_6Axis_MotionApps20.c iic_soft.c
  group driver
    ../user/driver/: usart.c stm32_flash.c can.c tim1.c adc.c tim5.c iic.c irq_dead_check.c tim3_4.c uart_dma.c flash.c data_save_lib.c UI_lib.c time.c
  group MAKOS
    ../MAKOS/migration/: makos_pendsv.c makos_critical.c makos_tick.c
    ../MAKOS/includes/: makos_doublelist.c makos_F2S.c
    ../MAKOS/kernel/: makos_memory.c makos_mutex.c makos_semaphore.c makos_pipe.c makos_task.c makos_system.c makos_message.c makos_schedule.c makos_tick_handle.c makos_dnode_queue.c makos_print.c makos_idle.c makos_resolver.c makos_irq_handle.c makos_record.c mak_print.c
  group STM32F4
    ../STM32F4/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40xx.s
    ../STM32F4/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
